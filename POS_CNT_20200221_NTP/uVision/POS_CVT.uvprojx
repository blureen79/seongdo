# Keil uVision project POS_CVT.uvprojx, settings and files
target POS_CVT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.29.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: POS_CNT +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: BOARD_CUSTOM FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=6  S132  SOFTDEVICE_PRESENT  SWI_DISABLE0  CONFIG_NFCT_PINS_AS_GPIOS  ND_DEBUG NO_SEGGER
  c misc: --reduce_paths
  c include: ..\Application\main;..\Driver;..\components;..\components\ble\ble_advertising;..\components\ble\ble_dtm;..\components\ble\ble_link_ctx_manager;..\components\ble\ble_racp;..\components\ble\ble_services\ble_ancs_c;..\components\ble\ble_services\ble_ans_c;..\components\ble\ble_services\ble_bas;..\components\ble\ble_services\ble_bas_c;..\components\ble\ble_services\ble_cscs;..\components\ble\ble_services\ble_cts_c;..\components\ble\ble_services\ble_dfu;..\components\ble\ble_services\ble_dis;..\components\ble\ble_services\ble_gls;..\components\ble\ble_services\ble_hids;..\components\ble\ble_services\ble_hrs;..\..\..\..\config;..\components\ble\ble_services\ble_hrs_c;..\components\ble\ble_services\ble_hts;..\components\ble\ble_services\ble_ias;..\components\ble\ble_services\ble_ias_c;..\components\ble\ble_services\ble_lbs;..\components\ble\ble_services\ble_lbs_c;..\components\ble\ble_services\ble_lls;..\components\ble\ble_services\ble_nus;..\components\ble\ble_services\ble_nus_c;..\components\ble\ble_services\ble_rscs;..\components\ble\ble_services\ble_rscs_c;..\components\ble\ble_services\ble_tps;..\components\ble\common;..\components\ble\nrf_ble_gatt;..\components\ble\nrf_ble_qwr;..\components\ble\peer_manager;..\components\boards;..\components\drivers_nrf\usbd;..\components\libraries\atomic;..\components\libraries\atomic_fifo;..\components\libraries\atomic_flags;..\components\libraries\balloc;..\components\libraries\bootloader\ble_dfu;..\components\libraries\bsp;..\components\libraries\button;..\components\libraries\cli;..\components\libraries\crc16;..\components\libraries\crc32;..\components\libraries\crypto;..\components\libraries\csense;..\components\libraries\csense_drv;..\components\libraries\delay;..\components\libraries\ecc;..\components\libraries\experimental_section_vars;..\components\libraries\experimental_task_manager;..\components\libraries\fds;..\components\libraries\fstorage;..\components\libraries\fifo;..\components\libraries\gfx;..\components\libraries\gpiote;..\components\libraries\hardfault;..\components\libraries\hci;..\components\libraries\led_softblink;..\components\libraries\log;..\components\libraries\log\src;..\components\libraries\low_power_pwm;..\components\libraries\mem_manager;..\components\libraries\memobj;..\components\libraries\mpu;..\components\libraries\mutex;..\components\libraries\pwm;..\components\libraries\pwr_mgmt;..\components\libraries\queue;..\components\libraries\ringbuf;..\components\libraries\scheduler;..\components\libraries\sdcard;..\components\libraries\sensorsim;..\components\libraries\slip;..\components\libraries\sortlist;..\components\libraries\spi_mngr;..\components\libraries\stack_guard;..\components\libraries\strerror;..\components\libraries\svc;..\components\libraries\timer;..\components\libraries\twi_mngr;..\components\libraries\twi_sensor;..\components\libraries\usbd;..\components\libraries\usbd\class\audio;..\components\libraries\usbd\class\cdc;..\components\libraries\usbd\class\cdc\acm;..\components\libraries\usbd\class\hid;..\components\libraries\usbd\class\hid\generic;..\components\libraries\usbd\class\hid\kbd;..\components\libraries\usbd\class\hid\mouse;..\components\libraries\usbd\class\msc;..\components\libraries\util;..\components\libraries\uart;..\components\nfc\ndef\conn_hand_parser;..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\components\nfc\ndef\connection_handover\ac_rec;..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\components\nfc\ndef\connection_handover\ble_pair_lib;..\components\nfc\ndef\connection_handover\ble_pair_msg;..\components\nfc\ndef\connection_handover\common;..\components\nfc\ndef\connection_handover\ep_oob_rec;..\components\nfc\ndef\connection_handover\hs_rec;..\components\nfc\ndef\connection_handover\le_oob_rec;..\components\nfc\ndef\generic\message;..\components\nfc\ndef\generic\record;..\components\nfc\ndef\launchapp;..\components\nfc\ndef\parser\message;..\components\nfc\ndef\parser\record;..\components\nfc\ndef\text;..\components\nfc\ndef\uri;..\components\nfc\t2t_lib;..\components\nfc\t2t_lib\hal_t2t;..\components\nfc\t2t_parser;..\components\nfc\t4t_lib;..\components\nfc\t4t_lib\hal_t4t;..\components\nfc\t4t_parser\apdu;..\components\nfc\t4t_parser\cc_file;..\components\nfc\t4t_parser\hl_detection_procedure;..\components\nfc\t4t_parser\tlv;..\components\softdevice\common;..\components\softdevice\s132\headers;..\components\softdevice\s132\headers\nrf52;..\components\toolchain\cmsis\include;..\external\fprintf;..\external\segger_rtt;..\external\utf_converter;..\integration\nrfx;..\integration\nrfx\legacy;..\modules\nrfx;..\modules\nrfx\drivers\include;..\modules\nrfx\hal;..\modules\nrfx\mdk;..\Application\main;..\Driver;..\components\softdevice\common;..\modules\nrfx\drivers\src\prs;..\RTT
  asm define: BOARD_CUSTOM FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=6  S132  SOFTDEVICE_PRESENT  SWI_DISABLE0  CONFIG_NFCT_PINS_AS_GPIOS  ND_DEBUG
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=6,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\Application\main;..\Driver;..\components;..\components\ble\ble_advertising;..\components\ble\ble_dtm;..\components\ble\ble_link_ctx_manager;..\components\ble\ble_racp;..\components\ble\ble_services\ble_ancs_c;..\components\ble\ble_services\ble_ans_c;..\components\ble\ble_services\ble_bas;..\components\ble\ble_services\ble_bas_c;..\components\ble\ble_services\ble_cscs;..\components\ble\ble_services\ble_cts_c;..\components\ble\ble_services\ble_dfu;..\components\ble\ble_services\ble_dis;..\components\ble\ble_services\ble_gls;..\components\ble\ble_services\ble_hids;..\components\ble\ble_services\ble_hrs;..\..\..\..\config;..\components\ble\ble_services\ble_hrs_c;..\components\ble\ble_services\ble_hts;..\components\ble\ble_services\ble_ias;..\components\ble\ble_services\ble_ias_c;..\components\ble\ble_services\ble_lbs;..\components\ble\ble_services\ble_lbs_c;..\components\ble\ble_services\ble_lls;..\components\ble\ble_services\ble_nus;..\components\ble\ble_services\ble_nus_c;..\components\ble\ble_services\ble_rscs;..\components\ble\ble_services\ble_rscs_c;..\components\ble\ble_services\ble_tps;..\components\ble\common;..\components\ble\nrf_ble_gatt;..\components\ble\nrf_ble_qwr;..\components\ble\peer_manager;..\components\boards;..\components\drivers_nrf\usbd;..\components\libraries\atomic;..\components\libraries\atomic_fifo;..\components\libraries\atomic_flags;..\components\libraries\balloc;..\components\libraries\bootloader\ble_dfu;..\components\libraries\bsp;..\components\libraries\button;..\components\libraries\cli;..\components\libraries\crc16;..\components\libraries\crc32;..\components\libraries\crypto;..\components\libraries\csense;..\components\libraries\csense_drv;..\components\libraries\delay;..\components\libraries\ecc;..\components\libraries\experimental_section_vars;..\components\libraries\experimental_task_manager;..\components\libraries\fds;..\components\libraries\fstorage;..\components\libraries\fifo;..\components\libraries\gfx;..\components\libraries\gpiote;..\components\libraries\hardfault;..\components\libraries\hci;..\components\libraries\led_softblink;..\components\libraries\log;..\components\libraries\log\src;..\components\libraries\low_power_pwm;..\components\libraries\mem_manager;..\components\libraries\memobj;..\components\libraries\mpu;..\components\libraries\mutex;..\components\libraries\pwm;..\components\libraries\pwr_mgmt;..\components\libraries\queue;..\components\libraries\ringbuf;..\components\libraries\scheduler;..\components\libraries\sdcard;..\components\libraries\sensorsim;..\components\libraries\slip;..\components\libraries\sortlist;..\components\libraries\spi_mngr;..\components\libraries\stack_guard;..\components\libraries\strerror;..\components\libraries\svc;..\components\libraries\timer;..\components\libraries\twi_mngr;..\components\libraries\twi_sensor;..\components\libraries\usbd;..\components\libraries\usbd\class\audio;..\components\libraries\usbd\class\cdc;..\components\libraries\usbd\class\cdc\acm;..\components\libraries\usbd\class\hid;..\components\libraries\usbd\class\hid\generic;..\components\libraries\usbd\class\hid\kbd;..\components\libraries\usbd\class\hid\mouse;..\components\libraries\usbd\class\msc;..\components\libraries\util;..\components\libraries\uart;..\components\nfc\ndef\conn_hand_parser;..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\components\nfc\ndef\connection_handover\ac_rec;..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\components\nfc\ndef\connection_handover\ble_pair_lib;..\components\nfc\ndef\connection_handover\ble_pair_msg;..\components\nfc\ndef\connection_handover\common;..\components\nfc\ndef\connection_handover\ep_oob_rec;..\components\nfc\ndef\connection_handover\hs_rec;..\components\nfc\ndef\connection_handover\le_oob_rec;..\components\nfc\ndef\generic\message;..\components\nfc\ndef\generic\record;..\components\nfc\ndef\launchapp;..\components\nfc\ndef\parser\message;..\components\nfc\ndef\parser\record;..\components\nfc\ndef\text;..\components\nfc\ndef\uri;..\components\nfc\t2t_lib;..\components\nfc\t2t_lib\hal_t2t;..\components\nfc\t2t_parser;..\components\nfc\t4t_lib;..\components\nfc\t4t_lib\hal_t4t;..\components\nfc\t4t_parser\apdu;..\components\nfc\t4t_parser\cc_file;..\components\nfc\t4t_parser\hl_detection_procedure;..\components\nfc\t4t_parser\tlv;..\components\softdevice\common;..\components\softdevice\s132\headers;..\components\softdevice\s132\headers\nrf52;..\components\toolchain\cmsis\include;..\external\fprintf;..\external\segger_rtt;..\external\utf_converter;..\integration\nrfx;..\integration\nrfx\legacy;..\modules\nrfx;..\modules\nrfx\drivers\include;..\modules\nrfx\hal;..\modules\nrfx\mdk;..\Application\main;..\Driver;..\components\softdevice\common;..\modules\nrfx\drivers\src\prs
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x20002aa8 size 0xd557
  link misc: --diag_suppress 6330
  group Application
    ../Application/main/: func.c main.c process_data.c shoponair.c sdk_config.h auto_baudrate.c play_sound.c pos_parser.c custom_board.h func.h process_data.h shoponair.h
  group Device
    ../modules/nrfx/mdk/: arm_startup_nrf52.s system_nrf52.c
  group NDeviceDriver
    ../Driver/: ndevice_ble.c ndevice_eeprom.c ndevice_gpio.c ndevice_nvmc.c ndevice_pwm.c ndevice_rnd.c ndevice_sadc.c ndevice_spi.c ndevice_timer.c ndevice_uart.c ndevice_util.c
  group NordicSDK
    ../components/libraries/log/src/: nrf_log_backend_flash.c nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
    ../components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c security_dispatcher.c security_manager.c
    ../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../components/ble/ble_advertising/: ble_advertising.c
    ../components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    ../integration/nrfx/legacy/: nrf_drv_clock.c
    ../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_wdt.c nrfx_pwm.c
    ../components/libraries/button/: app_button.c
    ../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c app_error_handler_keil.c
    ../components/libraries/fifo/: app_fifo.c
    ../components/libraries/scheduler/: app_scheduler.c
    ../components/libraries/timer/: app_timer.c
    ../components/libraries/crc16/: crc16.c
    ../components/libraries/hardfault/: hardfault_implementation.c
    ../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../components/libraries/atomic_flags/: nrf_atflags.c
    ../components/libraries/atomic/: nrf_atomic.c
    ../components/libraries/balloc/: nrf_balloc.c
    ../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../components/libraries/memobj/: nrf_memobj.c
    ../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../components/libraries/ringbuf/: nrf_ringbuf.c
    ../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../components/libraries/strerror/: nrf_strerror.c
    ../components/libraries/uart/: retarget.c
    ../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
